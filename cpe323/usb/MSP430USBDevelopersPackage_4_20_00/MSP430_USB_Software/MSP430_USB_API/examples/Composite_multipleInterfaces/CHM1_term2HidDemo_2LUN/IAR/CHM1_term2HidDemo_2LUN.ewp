# IAR project CHM1_term2HidDemo_2LUN.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xssfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../..; ../../../../driverlib/MSP430F5xx_6xx; ..; ../USB_config
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -P(CONST)MYDRIVE=0x10000-0x24400
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: hal.c hal.h main.c main.h system_pre_init.c
  group USB_app
    ../USB_app/: LUN0.c LUN0.h LUN0_data.c LUN0_data.h LUN1.c LUN1.h usbConstructs.c usbConstructs.h usbEventHandling.c
  group USB_app/FatFs
    ../USB_app/FatFs/: diskio.h ff.c ff.h ffconf.h HAL_SDCard.c HAL_SDCard.h mmc.c mmc.h
  group USB_config
    ../USB_config/: descriptors.c descriptors.h UsbIsr.c
  group USB_API
    ../../../../USB_API/: msp430USB.ld
  group USB_API/USB_CDC_API
    ../../../../USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    ../../../../USB_API/USB_Common/: defMSP430USB.h device.h types.h usb.c usb.h usbdma.c UsbIsr.h
  group USB_API/USB_HID_API
    ../../../../USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB_API/USB_MSC_API
    ../../../../USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB_API/USB_PHDC_API
    ../../../../USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group driverlib
    ../../../../driverlib/: release_notes.html
  group driverlib/MSP430F5xx_6xx
    ../../../../driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h eusci_i2c.c eusci_i2c.h eusci_spi.c eusci_spi.h eusci_uart.c eusci_uart.h flashctl.c flashctl.h gpio.c gpio.h ldopwr.c ldopwr.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h usci_i2c.c usci_i2c.h usci_spi.c usci_spi.h usci_uart.c usci_uart.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/deprecated
    ../../../../driverlib/MSP430F5xx_6xx/deprecated/: dma.c dma.h flashctl.c flashctl.h mpy32.c mpy32.h pmm.c pmm.h ram.c ram.h sfr.c sfr.h sysctl.c sysctl.h ucs.c ucs.h
  group driverlib/MSP430F5xx_6xx/deprecated/CCS
    ../../../../driverlib/MSP430F5xx_6xx/deprecated/CCS/: msp430f5xx_6xxgeneric.h
  group driverlib/MSP430F5xx_6xx/deprecated/IAR
    ../../../../driverlib/MSP430F5xx_6xx/deprecated/IAR/: msp430f5xx_6xxgeneric.h
  group driverlib/MSP430F5xx_6xx/inc
    ../../../../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
